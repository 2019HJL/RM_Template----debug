# Keil uVision project rm_template.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427II STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rm_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER
  c include: ..\Algorithm\Inc;..\Hardware\board\Inc;..\Hardware\chip\Inc;..\Hardware\external\Inc;..\Monitor\Inc;..\System\delay;..\System\sys;..\User;..\ST_Library\core;..\ST_Library\fwlib\inc;..\ST_Library;..\Debug_Tools\PID_Set;..\Debug_Tools\Report
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Algorithm
    ../Algorithm/Src/: ammunition_feed_ctrl.c buff.c chassis_power.c chassis_ctrl.c crc.c gimbal_ctrl.c level.c pid.c shooter_heat.c ramp.c friction_ctrl.c imu.c
  group Debug_Tools
    ../Debug_Tools/PID_Set/: pid_set.c
    ../Debug_Tools/Report/: report.c
  group Hardware_board
    ../Hardware/board/Src/: beep.c key.c led.c
  group Hardware_chip
    ../Hardware/chip/Src/: can.c dma.c gpio.c pwm.c spi.c tim.c usart.c mpu6050_i2c.c
  group Hardware_external
    ../Hardware/external/Src/: ammunition_feed.c chassis.c DR16.c external_gyro.c friction.c gimbal.c judge_data.c laser.c UWB.c VPU.c mpu6050_driver.c
  group Monitor
    ../Monitor/Src/: error_handing.c error_indicate.c system_reset.c watch_dog.c
  group ST_Library
    ../ST_Library/core/: core_cm4.h core_cm4_simd.h startup_stm32f427_437xx.s
    ../ST_Library/fwlib/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_iwdg.c
    ../ST_Library/: stm32f4xx_it.c system_stm32f4xx.c
  group System
    ../System/delay/: delay.c
    ../System/sys/: sys.c
  group User
    ./: main.c
